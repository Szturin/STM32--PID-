# Keil uVision project Project.uvprojx, settings and files
target Turin (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Driver;..\Library;..\Start;..\User;..\System;..\Driver\MPU6050;..\Driver\MPU6050_DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ../Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../System/: Delay.c Delay.h Timer.c Timer.h
  group Driver
    ../Driver/: Encoder.c Encoder.h Key.c Key.h Motor.c Motor.h OLED.c OLED.h OLED_Font.h PWM.c PWM.h Serial.c Serial.h PID.c PID.h
  group MPU6050
    ../Driver/MPU6050/: MPU6050.c MyIIC.c MPU6050.h MPU6050_Reg.h MyIIC.h MPU_EXIT.c MPU_EXIT.h
  group MPU6050_DMP
    ../Driver/MPU6050_DMP/: dmpKey.h inv_mpu.c dmpmap.h inv_mpu_dmp_motion_driver.c inv_mpu.h inv_mpu_dmp_motion_driver.h
  group User
    ./: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
